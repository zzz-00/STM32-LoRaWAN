# IAR project Project.ewp, settings and files
configuration STM32L476RG_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\RTOS\Template; ..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\inc\board; ..\inc\board\sensors; ..\inc\common; ..\inc\mcu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L476RG-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
